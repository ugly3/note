# Keil uVision project template.uvprojx, settings and files
target Target 1 (5050041::5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F407, __FPU_PRESENT
  c include: ..\BSP;..\CMSIS;..\Library\Include;..\User;..\BSP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: system_gd32f4xx.c
  group Startup
    ../Startup/: startup_gd32f407.s
  group Library
    ../Library/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group User
    ../User/: main.c systick.c gd32f4xx_it.c Task_Cycle.c Task_Cycle.h TIM.c TIM.h LED.c Buzz.c Buzz.h Walk_Motor.c Walk_Motor.h Key.c Key.h Fan.c Fan.h Servo.c Servo.h ShuMaGuan.c ShuMaGuan.h HC.c HC.h BH1750.c BH1750.h DHT11.c DHT11.h Mpu6050.c Mpu6050.h HX711.c HX711.h Hc595.c Hc595.h RC522.c RC522.h My_RFID_Check.c My_RFID_Check.h RTC.c RTC.h ADC.c ADC.h Usart.c Usart.h sys.c sys.h Body_Hw.c Body_Hw.h font.h iic.c iic.h oled.c oled.h ALL.h ALL.c
