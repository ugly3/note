# Keil uVision project CarV1.uvprojx, settings and files
target Car_Demo (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407IG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CarV1.7 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\CMSIS;..\FWLIB\inc;..\USER;..\HARDWARE\Task_Board;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\Core_Board;..\HARDWARE\CAN;..\my_lib;..\SYSTEM\timer;..\HARDWARE\Drive;..\MODULE\all_module;..\MODULE\android;..\MODULE\communication;..\MODULE\follow_car;..\MODULE\landmark;..\MODULE\mixture;..\MODULE\motor_drive;..\MODULE\xiaochuang;..\MODULE\landmark\barrier_gate;..\MODULE\landmark\etc;..\MODULE\landmark\led_display;..\MODULE\landmark\rfid;..\MODULE\landmark\smart_street_light;..\MODULE\landmark\smart_tft_display;..\MODULE\landmark\smart_traffic_light;..\MODULE\landmark\smoke_tower;..\MODULE\landmark\special_landform;..\MODULE\landmark\three_dim_carport;..\MODULE\landmark\three_dim_display;..\MODULE\landmark\voice_report;..\MODULE\landmark\wireless_charge;..\MODULE\landmark\two_code;..\MODULE\landmark\Algorithm;..\MODULE\landmark\DES_Algorithm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c Auto.c
  group MODULE
    ../MODULE/all_module/: all_module.c
    ../MODULE/mixture/: mixture.c
    ../MODULE/follow_car/: follow_car.c
    ../MODULE/android/: android.c
    ../MODULE/communication/: communication.c
    ../MODULE/motor_drive/: motor_drive.c
    ../MODULE/landmark/barrier_gate/: barrier_gate.c
    ../MODULE/landmark/etc/: etc.c
    ../MODULE/landmark/led_display/: led_display.c
    ../MODULE/landmark/rfid/: rfid.c
    ../MODULE/landmark/smart_street_light/: smart_street_light.c
    ../MODULE/landmark/smart_tft_display/: smart_tft_display.c
    ../MODULE/landmark/smart_traffic_light/: smart_traffic_light.c
    ../MODULE/landmark/special_landform/: special_landform.c
    ../MODULE/landmark/three_dim_carport/: three_dim_carport.c
    ../MODULE/landmark/three_dim_display/: three_dim_display.c
    ../HARDWARE/Task_Board/: tba.c
    ../MODULE/landmark/voice_report/: voice_report.c
    ../MODULE/landmark/wireless_charge/: wireless_charge.c
    ../MODULE/landmark/smoke_tower/: smoke_tower.c
    ../MODULE/xiaochuang/: xiaochuang.c
    ../MODULE/landmark/two_code/: two_code.c
    ../MODULE/landmark/Algorithm/: Algorithm.c
    ../MODULE/landmark/DES_Algorithm/: DES_Algorithm.c
  group HARDWARE
    ../HARDWARE/Task_Board/: infrared.c ultrasonic.c bh1750.c bkrc_voice.c
    ../HARDWARE/Core_Board/: cba.c usart.c power_check.c uart_a72.c uart_drv.c rc522.c
    ../HARDWARE/Drive/: drive.c
    ../my_lib/: swopt_drv.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/timer/: Timer.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../CMSIS/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group my_lib
    ../my_lib/: my_lib.c data_base.c roadway_check.c data_filtering.c
  group CAN
    ../HARDWARE/CAN/: can_drv.c CanP_HostCom.c fifo_drv.c Hard_Can.c can_user.c Can_check.c
